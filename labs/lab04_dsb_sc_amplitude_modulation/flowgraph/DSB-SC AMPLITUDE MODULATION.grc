options:
  parameters:
    author: Shreyansh Pandey
    generate_options: qt_gui
    id: am_simulation
    output_language: python
    title: AMPLITUDE MODULATION
  states: {}

blocks:
- name: baseband_amplitude
  id: variable_qtgui_range
  parameters:
    label: BASEBAND AMPLITUDE
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.5'
  states: {}
- name: baseband_frequency
  id: variable_qtgui_range
  parameters:
    label: BASEBAND FREQUENCY
    start: '0'
    step: '1'
    stop: '200'
    value: '40'
  states: {}
- name: carrier_frequency
  id: variable_qtgui_range
  parameters:
    label: CARRIER FREQUENCY
    start: '0'
    step: '1'
    stop: '16000'
    value: '1000'
  states: {}
- name: mod_depth
  id: variable_qtgui_label
  parameters:
    label: MODULATION DEPTH
    type: int
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\hp\Downloads\GNU RADIO\SAM AUDIO.wav
    repeat: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Modulation Depth = Baseband
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
