options:
  parameters:
    author: Shreyansh Pandey
    generate_options: qt_gui
    id: multipath_fading
    output_language: python
    title: MULTIPATH FADING - 2 RAY WIRELESS MODEL
  states: {}

blocks:
- name: avg
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: delay_1
  id: variable
  parameters:
    value: '80'
  states: {}
- name: delay_2
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: gain_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: gain_2
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\hp\Downloads\GNU RADIO\SAM AUDIO.wav
    repeat: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'TRACE 0:ORIGINAL '
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'TRACE 1: AFTER FADING'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: ORIGINAL_AFTER FADING
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: ORIGINAL_AFTER FADING
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
