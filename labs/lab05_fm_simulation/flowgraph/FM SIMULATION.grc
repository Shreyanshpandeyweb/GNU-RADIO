options:
  parameters:
    author: Shreyansh Pandey
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: FM SIMULATION
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: '20000'
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\hp\Downloads\GNU RADIO\SAM AUDIO.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '4000000'
    fc: '0'
    fftsize: '1024'
    name: FM TRANSMITTER
    showports: 'True'
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: '4000000'
    fc: '0'
    fftsize: '1024'
    name: FM_RECEIVER
    showports: 'True'
    showrf: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fm_str
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fm_str
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_1, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_1, '0', analog_wfm_rcv_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
