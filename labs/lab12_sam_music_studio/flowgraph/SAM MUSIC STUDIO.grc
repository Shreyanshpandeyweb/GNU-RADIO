options:
  parameters:
    author: Shreyansh Pandey
    generate_options: qt_gui
    id: sam_studio
    output_language: python
    title: SAM MUSIC STUDIO
  states: {}

blocks:
- name: echo_delay
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: echo_gain
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: echo_samples
  id: variable
  parameters:
    value: int(echo_delay * samp_rate)
  states: {}
- name: feedback_gain
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: mix
  id: variable
  parameters:
    value: '0.6'
  states: {}
- name: rev1_samples
  id: variable
  parameters:
    value: int(reverb1_delay * samp_rate)
  states: {}
- name: rev2_samples
  id: variable
  parameters:
    value: int(reverb2_delay * samp_rate)
  states: {}
- name: rev3_samples
  id: variable
  parameters:
    value: int(reverb3_delay * samp_rate)
  states: {}
- name: reverb1_delay
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: reverb2_delay
  id: variable
  parameters:
    value: '0.07'
  states: {}
- name: reverb3_delay
  id: variable
  parameters:
    value: '0.12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: echo_samples
    type: float
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: ' rev1_samples'
    type: float
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: ' rev2_samples'
    type: float
  states: {}
- name: blocks_delay_1_1
  id: blocks_delay
  parameters:
    delay: ' rev3_samples'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: echo_gain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 - mix
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: feedback_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: feedback_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: feedback_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    const: mix
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\hp\Downloads\GNU RADIO\SAM AUDIO.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '3'
    type: float
  states: {}

connections:
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_5, '0']
- [blocks_add_xx_2, '0', audio_sink_0, '0']
- [blocks_add_xx_2, '0', qtgui_freq_sink_x_0, '2']
- [blocks_add_xx_2, '0', qtgui_time_sink_x_0, '2']
- [blocks_add_xx_2, '0', qtgui_waterfall_sink_x_0, '2']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_delay_1_0, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_delay_1_1, '0', blocks_multiply_const_vxx_4, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_2, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_4, '0', blocks_add_xx_1, '2']
- [blocks_multiply_const_vxx_5, '0', blocks_add_xx_2, '1']
- [blocks_multiply_const_vxx_5, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_5, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_5, '0', qtgui_waterfall_sink_x_0, '1']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_1, '0']
- [blocks_throttle2_0, '0', blocks_delay_1_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_1_1, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
